# Keil uVision project LCDDataRead.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: LCDDataRead +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LIB
  link misc: REMOVEUNUSED
  group USER
    ./LIB/: STC8A_ADC_Isr.c STC8A_Timer_Isr.c
    ./: STARTUP.A51 main.c oled.c PowerCheck.c ADC.c timer.c timer.h uart.c uart.h
  group LIB
    ./LIB/: STC8A_ADC.c STC8A_Compare.c STC8A_Compare_Isr.c STC8A_Delay.c STC8A_DMA.c STC8A_DMA_Isr.c STC8A_EEPROM.c STC8A_Exti.c STC8A_Exti_Isr.c STC8A_GPIO.c STC8A_GPIO_Isr.c STC8A_I2C.c STC8A_I2C_Isr.c STC8A_LCM.c STC8A_NVIC.c STC8A_PCA.c STC8A_PCA_Isr.c STC8A_PWM15bit.c STC8A_PWM15bit_Isr.c STC8A_Soft_I2C.c STC8A_Soft_UART.c STC8A_SPI.c STC8A_SPI_Isr.c STC8A_Timer.c STC8A_UART.c STC8A_UART_Isr.c STC8A_WDT.c
